# Keil uVision project ISP_HID.uvproj, settings and files
target ISP_HID (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: I91500 Nuvoton
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0-0xFFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: I91500_ISP_HID
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\I91500\Include;..\..\..\..\Library\StdDriver\inc
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --map --first='startup_i91500_keil.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ./: startup_I91500_keil.s
    ../../../../Library/Device/Nuvoton/I91500/Source/: system_I91500.c
  group User
    ../: main.c fmc_user.c targetdev.c isp_user.c usbd_user.c hid_trans.c hid_transdesc.c
  group Libraries
    ../../../../Library/StdDriver/src/: sys.c clk.c gpio.c fmc.c
