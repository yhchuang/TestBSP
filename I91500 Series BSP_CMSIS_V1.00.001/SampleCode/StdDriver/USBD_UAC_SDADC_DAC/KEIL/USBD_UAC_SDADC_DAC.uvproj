# Keil uVision project USBD_UAC_SDADC_DAC.uvproj, settings and files
target I91500 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: I91500 Nuvoton
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0-0xFFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: USBD_UAC_SDADC_DAC
  AfterMake: fromelf --bin ".\I91500\@L.axf" --output ".\I91500\@L.bin"
  AfterMake: fromelf --text -c ".\I91500\@L.axf" --output ".\I91500\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __I91500__
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\I91500\Include;..\..\..\..\Library\StdDriver\inc
  asm define: __I91500__
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --map --first='startup_i91500_keil.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ./: startup_I91500_keil.s
    ../../../../Library/Device/Nuvoton/I91500/Source/: system_I91500.c
  group User
    ../: main.c hirc_trim.c descriptors.c usbd_audio.c peripheral.c audio_stream.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c usbd.c pdma.c dac.c biq.c sdadc.c ana.c
